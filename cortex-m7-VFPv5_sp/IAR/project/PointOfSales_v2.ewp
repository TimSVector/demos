# IAR project PointOfSales_v2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCIncludePath2: D:\vector\github\demos\cortex-m7-VFPv5_sp\IAR\code\database\inc; D:\vector\github\demos\cortex-m7-VFPv5_sp\IAR\code\encrypt\inc; D:\vector\github\demos\cortex-m7-VFPv5_sp\IAR\code\order_entry\inc; D:\vector\github\demos\cortex-m7-VFPv5_sp\IAR\code\utils\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PointOfSales_v2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkExtraOptions: --redirect __write=__write_buffered
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group inc
    ../code/order_entry/inc/: ctypes.h manager.h waiting_list.h
    ../code/database/inc/: database.h
    ../code/encrypt/inc/: encrypt.h matrix_multiply.h
    ../code/utils/inc/: linked_list.h
  group src
    ../code/database/src/: database.c
    ../code/encrypt/src/: encrypt.c matrix_multiply.c
    ../code/utils/src/: linked_list.c whitebox.c
    ../code/order_entry/src/: manager.c waiting_list.c
    ../code/main/: pos_driver.c
